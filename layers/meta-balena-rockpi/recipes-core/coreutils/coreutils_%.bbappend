EXTRA_OECONF:append = " ac_cv_func_statx=no"
