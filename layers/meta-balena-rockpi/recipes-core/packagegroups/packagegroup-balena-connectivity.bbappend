CONNECTIVITY_FIRMWARES:append:rockpi-4b-rk3399 = " \
	rkwifibt-firmware-ap6212a1-bt \
	rkwifibt-firmware-ap6212a1-wifi \
"
