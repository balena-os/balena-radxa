# write internal balenaOS image to the eMMC
INTERNAL_DEVICE_KERNEL = "mmcblk1"
