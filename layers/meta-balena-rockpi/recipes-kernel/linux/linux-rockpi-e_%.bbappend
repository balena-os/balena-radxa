inherit kernel-balena